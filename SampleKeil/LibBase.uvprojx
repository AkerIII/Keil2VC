# Keil uVision project LibBase.uvprojx, settings and files
target DebugH (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: DebugH +hex
  c flags: Optim=1
  c define: __IN_CHIP
  c include: ..\Header;..\Logic;..\GeneratedCode
  asm define: REMAP RAM_MODE
  asm include: ..\Header
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000080 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: ..\ZY_CODE\Scf\ChipFlashH.scf
  link misc: --entry  0x00000000
  group Source
    ../Source/: fRamDrv.c funCode.c HwInterface.c IAP.c io.c ISR.c lpc2478AD.c lpc2478Can.c lpc2478Clkpwr.c lpc2478Pin.c lpc2478Rtc.c lpc2478Timer.c lpc2478Uart.c lpc2478Vic.c lpc2478Wdt.c main.c mvbD113lDrive.c mvbDrive.c nFlashDrv.c PwmCapture.c sdramDrv.c systemInit.c Table.c target.c task.c TcpData.c IRQ.s Startup.s vicControl.s BoardTest.c lpc4333_rtc_M0.c
    ../LibSource/: Bus.c canCommu.c faultProcess.c FlashDataManage.c framApp.c key.c maintain.c mvbCommu.c net.c scuKeyDeal.c
  group Head
    ../Header/: Bus.h canCommu.h config.h Define_2478.h faultProcess.h FlashDataManage.h framApp.h fRamDrv.h funCode.h GlobalTimer.h HwInterface.h IAP.h io.h IODef.h key.h LogicD10.h LogicFunction.h LPC2400.h LPC2400.inc lpc2478AD.h lpc2478Can.h lpc2478Clkpwr.h lpc2478Pin.h lpc2478Rtc.h lpc2478Timer.h lpc2478Uart.h lpc2478Vic.h lpc2478Wdt.h maintain.h mcs_def.h mvb_dcu.h mvb_def.h mvb_drive.h mvb_gf.h mvb_lp.h mvbCommu.h mvbD113lDrive.h my_define.h net.h nFlashDrv.h Power.h PwmCapture.h rs485.h save.h scuKeyDeal.h sdramDrv.h sysTest.h Table.h target.h task.h TcpData.h Type.h vicControl.h
  group Logic
    ../Logic/: LogicD10.c ScuLogicPartener.c
    ../GeneratedCode/: ScuLogic.c
    ../Source/: LogicFunction.c
target DebugL (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: as above
  output: DebugL +hex
  c flags: Optim=1
  c define: __IN_CHIP
  c include: ..\Header;..\Logic;..\GeneratedCode
  asm define: REMAP RAM_MODE
  asm include: ..\Header
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000080 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: ..\ZY_CODE\Scf\ChipFlashL.scf
  link misc: --entry  0x00000000
